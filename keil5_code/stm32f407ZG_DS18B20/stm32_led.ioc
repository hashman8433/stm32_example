# file: stm32_led.ioc
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Mcu.Family=STM32F4
Mcu.Name=STM32F407Z(E-G)Tx
Mcu.Package=LQFP144
NVIC.PriorityGroup=NVIC_PRIORITYGROUP_4
PE3.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_PP
PE3.GPIO_PuPd=GPIO_PULLUP
PE3.GPIO_Speed=GPIO_SPEED_HIGH
PE3.Signal=GPIO_Output
ProjectManager.TargetToolchain=MDK-ARM V5
RCC.48MHZClocksFreq_Value=48000000
RCC.AHBFreq_Value=16000000
RCC.APB1Freq_Value=16000000
RCC.APB2Freq_Value=16000000
RCC.CortexFreq_Value=16000000
RCC.HSE_VALUE=25000000
RCC.HSI_VALUE=16000000
RCC.LSE_VALUE=32768
RCC.SYSCLKFreq_VALUE=16000000
RCC.VCOOutputFreq_Value=192000000
board=stm32_led

// file: Src/main.c
/**
  ******************************************************************************
  * File Name          : main.c
  * Description        : Main program body
  ******************************************************************************
  *
  * COPYRIGHT(c) 2019 STMicroelectronics
  *
  * Redistribution and use in source and binary forms, with or without modification,
  * are permitted provided that the following conditions are met:
  *   1. Redistributions of source code must retain the above copyright notice,
  *      this list of conditions and the following disclaimer.
  *   2. Redistributions in binary form must reproduce the above copyright notice,
  *      this list of conditions and the following disclaimer in the documentation
  *      and/or other materials provided with the distribution.
  *   3. Neither the name of STMicroelectronics nor the names of its contributors
  *      may be used to endorse or promote products derived from this software
  *      without specific prior written permission.
  *
  * THIS SOFTWARE IS PROVIDED BY THE COPYRIGHT HOLDERS AND CONTRIBUTORS "AS IS"
  * AND ANY EXPRESS OR IMPLIED WARRANTIES, INCLUDING, BUT NOT LIMITED TO, THE
  * IMPLIED WARRANTIES OF MERCHANTABILITY AND FITNESS FOR A PARTICULAR PURPOSE ARE
  * DISCLAIMED. IN NO EVENT SHALL THE COPYRIGHT HOLDER OR CONTRIBUTORS BE LIABLE
  * FOR ANY DIRECT, INDIRECT, INCIDENTAL, SPECIAL, EXEMPLARY, OR CONSEQUENTIAL
  * DAMAGES (INCLUDING, BUT NOT LIMITED TO, PROCUREMENT OF SUBSTITUTE GOODS OR
  * SERVICES; LOSS OF USE, DATA, OR PROFITS; OR BUSINESS INTERRUPTION) HOWEVER
  * CAUSED AND ON ANY THEORY OF LIABILITY, WHETHER IN CONTRACT, STRICT LIABILITY,
  * OR TORT (INCLUDING NEGLIGENCE OR OTHERWISE) ARISING IN ANY WAY OUT OF THE USE
  * OF THIS SOFTWARE, EVEN IF ADVISED OF THE POSSIBILITY OF SUCH DAMAGE.
  *
  ******************************************************************************
  */
#define HIGH GPIO_PIN_SET
#define LOW GPIO_PIN_RESET
#define LED_ON HAL_GPIO_WritePin(GPIOE, GPIO_PIN_5, LOW);
#define LED_OFF HAL_GPIO_WritePin(GPIOE, GPIO_PIN_5, HIGH);
#define LED1_ON HAL_GPIO_WritePin(GPIOE, GPIO_PIN_6, LOW);
#define LED1_OFF HAL_GPIO_WritePin(GPIOE, GPIO_PIN_6, HIGH);

#include "stm32f4xx_hal.h"

/* USER CODE BEGIN PV */
/* Private variables ---------------------------------------------------------*/

/* USER CODE END PV */

void SystemClock_Config(void);
static void MX_GPIO_Init(void);
static void delay_us(uint16_t);
static void delay_ms(uint16_t);
static float DS18B20_Get_Temp(void);
static uint8_t DS18B20_Check(void);
static void start_slot(void);
static void DS1820_MODE_IN(void);
/* USER CODE BEGIN PFP */
/* Private function prototypes -----------------------------------------------*/

/* USER CODE END PFP */

float templature;
int main(void)
{

  /* MCU Configuration----------------------------------------------------------*/

  /* Reset of all peripherals, Initializes the Flash interface and the Systick. */
  HAL_Init();

  /* Configure the system clock */
  SystemClock_Config();

  /* Initialize all configured peripherals */
  MX_GPIO_Init();

  /* Infinite loop */
  /* USER CODE BEGIN WHILE */
	HAL_GPIO_WritePin(GPIOE, GPIO_PIN_5, HIGH);
	HAL_GPIO_WritePin(GPIOE, GPIO_PIN_6, HIGH);
  while (1)
  {
  /* USER CODE END WHILE */

  /* USER CODE BEGIN 3 */

		if(!DS18B20_Check()) {
			templature = DS18B20_Get_Temp();
			//LED_ON;
			// printf("\r\n no ds18b20 exit \r\n");
		}else {
			LED_OFF;
		}
		delay_ms(200);

		/**
		DS1820_MODE_IN();
		if (HAL_GPIO_ReadPin(GPIOB, GPIO_PIN_6))
			LED_ON
		else
			LED_OFF

		delay_ms(200);
		*/
  }
  /* USER CODE END 3 */

}

/** System Clock Configuration
*/
void SystemClock_Config(void)
{

  RCC_OscInitTypeDef RCC_OscInitStruct;
  RCC_ClkInitTypeDef RCC_ClkInitStruct;

  __PWR_CLK_ENABLE();
  __HAL_PWR_VOLTAGESCALING_CONFIG(PWR_REGULATOR_VOLTAGE_SCALE2);

  RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSI;
  RCC_OscInitStruct.HSIState = RCC_HSI_ON;
  RCC_OscInitStruct.HSICalibrationValue = 16;
  RCC_OscInitStruct.PLL.PLLState = RCC_PLL_ON;
  RCC_OscInitStruct.PLL.PLLSource = RCC_PLLSOURCE_HSI;
  RCC_OscInitStruct.PLL.PLLM = 8;
  RCC_OscInitStruct.PLL.PLLN = 216;
  RCC_OscInitStruct.PLL.PLLP = RCC_PLLP_DIV6;
  RCC_OscInitStruct.PLL.PLLQ = 4;
  HAL_RCC_OscConfig(&RCC_OscInitStruct);

  RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_SYSCLK|RCC_CLOCKTYPE_PCLK1;
  RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_PLLCLK;
  RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
  RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV2;
  RCC_ClkInitStruct.APB2CLKDivider = RCC_HCLK_DIV1;
  HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_2);

  HAL_SYSTICK_Config(HAL_RCC_GetHCLKFreq()/1000);

  HAL_SYSTICK_CLKSourceConfig(SYSTICK_CLKSOURCE_HCLK);

}

/**
	ds18b20 引脚 推挽 输出模式
*/
static void DS18B20_Mode_OUT(void) {
	/* 溫度计 引脚 B7 */
	GPIO_InitTypeDef GPIO_InitStruct;

  /* GPIO Ports Clock Enable */
  __GPIOB_CLK_ENABLE();

  /*Configure GPIO pin : PE5 */
  GPIO_InitStruct.Pin = GPIO_PIN_6;
  GPIO_InitStruct.Mode = GPIO_MODE_OUTPUT_PP;
  GPIO_InitStruct.Pull = GPIO_PULLUP;
  GPIO_InitStruct.Speed = GPIO_SPEED_HIGH;
  HAL_GPIO_Init(GPIOB, &GPIO_InitStruct);

}

/**
	切换为输入模式
*/
static void DS1820_MODE_IN(void) {

	GPIO_InitTypeDef GPIO_InitStruct;

	GPIO_InitStruct.Pin = GPIO_PIN_6;
	GPIO_InitStruct.Mode = GPIO_MODE_INPUT;	 // 浮空输入模式
  GPIO_InitStruct.Pull = GPIO_PULLDOWN;
	HAL_GPIO_Init(GPIOB, &GPIO_InitStruct);

	GPIO_InitTypeDef GPIO_InitStructure1;

	GPIO_InitStructure1.Pin = GPIO_PIN_7;
	GPIO_InitStructure1.Mode = GPIO_MODE_INPUT;	 // 浮空输入模式
	GPIO_InitStructure1.Pull  = GPIO_PULLUP;
	HAL_GPIO_Init(GPIOB, &GPIO_InitStructure1);
}

/**
	复位信号
*/
static void DS18B20_Rst(void) {

	DS18B20_Mode_OUT();
	/* 拉高 B5 电平 */
	HAL_GPIO_WritePin(GPIOB, GPIO_PIN_6, LOW);
	delay_us(750);
	HAL_GPIO_WritePin(GPIOB, GPIO_PIN_6, HIGH);
	delay_us(15);

}

/**
	检测 是否返回 低电平脉冲
*/
static uint8_t DS18B20_Presence(void) {

	uint8_t pulse_time = 0;

	DS1820_MODE_IN();

	while ( HAL_GPIO_ReadPin(GPIOB, GPIO_PIN_6) && pulse_time < 100 ) {
		pulse_time++;
		delay_us(1);
	}

	if( pulse_time >=100 )
		return 1;
	else
		pulse_time = 0;

	while( !HAL_GPIO_ReadPin(GPIOB, GPIO_PIN_6) && pulse_time < 240 )
	{
		pulse_time++;
		delay_us(1);
	}
	if( pulse_time >=240 )
		return 1;
	else
		return 0;

}

static uint8_t DS18B20_Check(void) {
	DS18B20_Rst();
	return DS18B20_Presence();
}

// 开始时序
void start_slot() {
	DS18B20_Mode_OUT();
	HAL_GPIO_WritePin(GPIOB, GPIO_PIN_6, LOW);
	delay_us(10);
	DS1820_MODE_IN();
}

/**
	读取 ds18b20 字节
*/

uint8_t DS18B20_Read_Byte(void)
{
	uint8_t i, j, z = 0;
	uint8_t dat = 0;

	for(i=0; i<8; i++)
	{
		start_slot();
		j = HAL_GPIO_ReadPin(GPIOB, GPIO_PIN_6);
		if (j)
			dat = (dat) | (1<<i);

		delay_us(45);
	}

	return dat;
}

/**
	写入 ds18b20 字节
*/

void DS18B20_Write_Byte(uint8_t dat)
{
	uint8_t i, testb;

	DS18B20_Mode_OUT();

	for( i=0; i<8; i++ )
	{
		testb = dat&0x01;
		dat = dat>>1;

		// start_slot();

		if (testb)
		{
			HAL_GPIO_WritePin(GPIOB, GPIO_PIN_6, LOW);
			delay_us(8);

			HAL_GPIO_WritePin(GPIOB, GPIO_PIN_6, HIGH);
			delay_us(60);
		}
		else
		{
			HAL_GPIO_WritePin(GPIOB, GPIO_PIN_6, LOW);
			/* 60us < Tx 0 < 120us */
			delay_us(70);

			HAL_GPIO_WritePin(GPIOB, GPIO_PIN_6, HIGH);

			delay_us(2);
		}

	}
}

/**************************************************************************************
	获取温度信息
 **************************************************************************************/

float DS18B20_Get_Temp(void)
{

	uint8_t tpmsb, tplsb;
	short s_tem;
	float f_tem;

	DS18B20_Rst();
	DS18B20_Presence();
	DS18B20_Write_Byte(0XCC);
	DS18B20_Write_Byte(0X44);
	delay_ms(200);

	DS18B20_Rst();
  DS18B20_Presence();
	DS18B20_Write_Byte(0XCC);
  DS18B20_Write_Byte(0XBE);
	tplsb = DS18B20_Read_Byte();
	tpmsb = DS18B20_Read_Byte();

	s_tem = tpmsb<<8;
	s_tem = s_tem | tplsb;

	for (int i = 0; i < 16; i++) {
		if(s_tem&(1<<i)) {
			LED_ON
			LED1_ON

		} else {
			LED_ON
			LED1_OFF
		}
		delay_ms(2000);
		LED_OFF
		LED1_OFF
		delay_ms(2000);
	}

	if( s_tem < 0 )
		f_tem = (~s_tem+1) * 0.0625;
	else
		f_tem = s_tem * 0.0625;

	return f_tem;
}

/** Configure pins as
        * Analog
        * Input
        * Output
        * EVENT_OUT
        * EXTI
*/
void MX_GPIO_Init(void)
{

  GPIO_InitTypeDef GPIO_InitStruct;

  /* GPIO Ports Clock Enable */
  __GPIOE_CLK_ENABLE();
	__GPIOB_CLK_ENABLE();

  /*Configure GPIO pin : PE5 */
  GPIO_InitStruct.Pin = GPIO_PIN_5;
  GPIO_InitStruct.Mode = GPIO_MODE_OUTPUT_PP;
  GPIO_InitStruct.Pull = GPIO_PULLUP;
  GPIO_InitStruct.Speed = GPIO_SPEED_HIGH;
  HAL_GPIO_Init(GPIOE, &GPIO_InitStruct);

	GPIO_InitTypeDef GPIO_InitStruct1;
	 /*Configure GPIO pin : PE5 */
  GPIO_InitStruct1.Pin = GPIO_PIN_6;
  GPIO_InitStruct1.Mode = GPIO_MODE_OUTPUT_PP;
  GPIO_InitStruct1.Pull = GPIO_PULLUP;
  GPIO_InitStruct1.Speed = GPIO_SPEED_HIGH;
  HAL_GPIO_Init(GPIOE, &GPIO_InitStruct1);

}

void delay_us(uint16_t us)
{
  uint16_t i;

	do
  {
    i = 6;
		while(i--)__nop();
  } while (--us);

}

void delay_ms(uint16_t ms)
{
  do
  {
    delay_us(250);
    delay_us(250);
		delay_us(250);
		delay_us(250);
  } while (--ms);
}

/************************ (C) COPYRIGHT STMicroelectronics *****END OF FILE****/
